# Keil uVision project Source.uvprojx, settings and files
target Source (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF)  CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Source +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030x6,USE_HAL_DRIVER,STM32F030x6
  c include: ../Inc;                      ../Drivers/STM32F0xx_HAL_Driver/Inc;                      ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;                      ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;                      ../Drivers/CMSIS/Include;                      ../ds18b20Lib;                      ../i2c LCD;                      ../NEC Transmitter;                      ../Buzzer;                      ../AT24C02
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Application/MDK-ARM
    ./: startup_stm32f030x6.s
  group Application/User
    ../Src/: main.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group DS18B20
    ../ds18b20Lib/: ds18b20.c onewire.c
  group IR Remote
    ../NEC Transmitter/: delay_us.c Generaltec AC Remote Transmitter.c
  group LCD
    ../i2c LCD/: 1602 LCD i2c.c
  group Buzzer
    ../Buzzer/: Buzzer.c
  group AT24C
    ../AT24C02/: at24_hal_i2c.c
software components: CMSIS:CORE 4.3.0
